Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: R:\eigene Vorgänge\250117 BIM Website Abgleich\3D Daten\SLE02-V.IFC
Time: 2025-01-17T09:25:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
